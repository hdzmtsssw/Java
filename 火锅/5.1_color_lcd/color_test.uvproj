# Keil uVision project color_test.uvproj, settings and files
target color_test (ARM-ADS)
  device: S3C44B0X Samsung
  cpu: IRAM(0x10000000-0x10001FFF) CLOCK(66000000) CPUTYPE(ARM7TDMI)
  output: obj
  c flags: Optim=1
  c include: ..\common\include
  asm include: ..\common\include
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0xc000000 size 0x800000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: ..\common\RuninRAM.sct
  group Source
    ./: main.c bmp.c bmp_data.c lcd.c ascii6x8.c ascii8x16.c
    ../5.2_keyboard_test/: keyboard.c iic.c 8led.c
  group Include
    ./: bmp.h lcd.h
  group Script
    ../common/: RuninFlash.sct RuninRAM.sct
  group Common
    ../common/src/: uhal.c 44blib.c S3C44B0X.s
  group ReadMe
    ./: readme.txt
    ../common/: ReadMeCommon.txt
